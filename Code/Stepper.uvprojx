# Keil uVision project Stepper.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Stepper +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: HD44780.h LCD.c LCD.h LEDs.c LEDs.h main.c servo.c servo.h startup_stm32f303xe.s stm32f30xe.h stm32f303xe.h SysClock.c SysClock.h system_stm32f3xx.c SysTick.c SysTick.h utils.h DRV8884.c DRV8884.h TIM17.c TIM17.h TIM16.c TIM16.h lim_sw.c lim_sw.h DRV8814.c DRV8814.h TIM3.c TIM3.h encoders.c encoders.h TIM15.c TIM15.h serial.c serial.h RTC.c RTC.h
software components: CMSIS:CORE 5.2.0
